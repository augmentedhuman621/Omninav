# Keil uVision project OmniNav_STM32.uvprojx, settings and files
target OmniNav_STM32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OmniNav_STM32 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: -std=gnu99
  c include: ../Inc;../../firmware_core/include;C:/Users/ASUS/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.7/Drivers/CMSIS/Device/ST/STM32F1xx/Include;C:/Users/ASUS/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.7/Drivers/CMSIS/Include;C:/Users/ASUS/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.7/Drivers/STM32F1xx_HAL_Driver/Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group firmware_core
    ../../firmware_core/src/: mecanum.c pid.c odom.c fixedpoint.c protocol.c
    ../Src/: core_selftest.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Example/User
    ../Src/: main.c bench.c usart2_bench.c app_single_wheel.c stm32f1xx_hal_msp.c stm32f1xx_it.c
  group Example/MDK-ARM
    ./: startup_stm32f103xe.s
  group Doc
    ../: readme.txt
  group Drivers/STM32F1xx_HAL_Driver
    C:/Users/ASUS/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.7/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_dma.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_sd.c stm32f1xx_hal_uart.c stm32f1xx_hal_dac.c stm32f1xx_ll_usb.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_nand.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_i2c.c stm32f1xx_hal_pcd.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_nor.c stm32f1xx_hal_rtc.c stm32f1xx_hal_wwdg.c stm32f1xx_hal_sram.c stm32f1xx_hal_can.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_usart.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_cortex.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_pccard.c stm32f1xx_hal_hcd.c stm32f1xx_ll_sdmmc.c stm32f1xx_hal.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_irda.c stm32f1xx_hal_adc.c stm32f1xx_hal_eth.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2s.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_crc.c stm32f1xx_hal_cec.c
software components: CMSIS:CORE 5.3.0
